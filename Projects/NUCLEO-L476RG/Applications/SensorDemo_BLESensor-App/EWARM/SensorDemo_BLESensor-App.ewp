# IAR project SensorDemo_BLESensor-App.ewp, settings and files
configuration SensorDemo_BLESensor-App (ARM, debug)
  General.OGChipSelectEditMenu: STM32L476RG ST STM32L476RG
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32L476xx
  ICCARM.CCIncludePath2: ../Inc; ../../../../../Drivers/STM32L4xx_HAL_Driver/Inc; ../../../../../Drivers/STM32L4xx_HAL_Driver/Inc/Legacy; ../../../../../Drivers/CMSIS/Device/ST/STM32L4xx/Include; ../../../../../Drivers/CMSIS/Include; ../../../../../Middlewares/ST/BlueNRG-2/hci/hci_tl_patterns/Basic; ../../../../../Middlewares/ST/BlueNRG-2/utils; ../../../../../Middlewares/ST/BlueNRG-2/includes
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: SensorDemo_BLESensor-App_L476RG.bin
  ILINK.IlinkOutputFile: SensorDemo_BLESensor-App.out
  ILINK.IlinkIcfFile: stm32l476xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32l476xx.s
  group Application/User
    ../Src/: app_bluenrg_2.c gatt_db.c hci_tl_interface.c main.c OTA.c sensor.c stm32l4xx_hal_msp.c stm32l4xx_it.c stm32l4xx_nucleo.c stm32l4xx_nucleo_bus.c target_platform.c
  group Drivers/CMSIS
    ../Src/: system_stm32l4xx.c
  group Drivers/STM32L4xx_HAL_Driver
    ../../../../../Drivers/STM32L4xx_HAL_Driver/Src/: stm32l4xx_hal.c stm32l4xx_hal_cortex.c stm32l4xx_hal_crc.c stm32l4xx_hal_crc_ex.c stm32l4xx_hal_dma.c stm32l4xx_hal_dma_ex.c stm32l4xx_hal_exti.c stm32l4xx_hal_flash.c stm32l4xx_hal_flash_ex.c stm32l4xx_hal_flash_ramfunc.c stm32l4xx_hal_gpio.c stm32l4xx_hal_i2c.c stm32l4xx_hal_i2c_ex.c stm32l4xx_hal_pwr.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_rcc.c stm32l4xx_hal_rcc_ex.c stm32l4xx_hal_spi.c stm32l4xx_hal_spi_ex.c stm32l4xx_hal_tim.c stm32l4xx_hal_tim_ex.c stm32l4xx_hal_uart.c stm32l4xx_hal_uart_ex.c
  group Middlewares/BlueNRG-2/Wireless/BlueNRG-2/Controller
    ../../../../../Middlewares/ST/BlueNRG-2/hci/controller/: bluenrg1_gap_aci.c bluenrg1_gatt_aci.c bluenrg1_hal_aci.c bluenrg1_l2cap_aci.c
  group Middlewares/BlueNRG-2/Wireless/BlueNRG-2/HCI_TL/Basic
    ../../../../../Middlewares/ST/BlueNRG-2/hci/: bluenrg1_devConfig.c bluenrg1_events.c bluenrg1_events_cb.c bluenrg1_hci_le.c
    ../../../../../Middlewares/ST/BlueNRG-2/hci/hci_tl_patterns/Basic/: hci_tl.c
  group Middlewares/BlueNRG-2/Wireless/BlueNRG-2/Utils
    ../../../../../Middlewares/ST/BlueNRG-2/utils/: ble_list.c
