<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\SensorDemo_BLESensor-App.ewp</path>
  </project>
  <batchBuild />
</workspace>
